# Keil uVision project canopen-slave.uvprojx, settings and files
target canopen-slave (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\core;..\lib\inc;..\user;..\bsp;..\canopen;..\canopen\include;..\canopen\include\stm32f103;..\canopen\objdict;..\canopen\ds401
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: core_cm3.c system_stm32f10x.c
    ../core/startup/: startup_stm32f10x_md.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_can.c bsp_key.c
  group canopen-core
    ../canopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group canopen-objdict
    ../canopen/objdict/: TestSlave.c ds402_state.h ds402_state.c
  group canopen-app
    ../canopen/: can_app.h can_app.c
  group user
    ../user/: main.c generator.h generator.c torque.h torque.c g4_motor.h g4_motor.c stm32f10x_it.c usart.h usart.c sys.h sys.c delay.h delay.c
